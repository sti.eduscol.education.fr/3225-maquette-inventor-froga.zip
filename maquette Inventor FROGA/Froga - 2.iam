# Autodesk Inventor assembly: Froga
## iProperties
Created: 2009-09
Part Number: Froga
Document SubType Name: Assembly
Designer: Olivier
Author: Olivier
